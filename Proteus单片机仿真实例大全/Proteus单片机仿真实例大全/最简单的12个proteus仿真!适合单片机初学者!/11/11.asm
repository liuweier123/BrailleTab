Second		EQU 30H
		ORG 0
START:		MOV Second,#00H
NEXT:		MOV A,Second
		MOV B,#10
		DIV AB
		MOV DPTR,#TABLE
		MOVC A,@A+DPTR
		MOV P0,A
		MOV A,B
		MOVC A,@A+DPTR
		MOV P2,A
		LCALL DELY1S
		INC Second
		MOV A,Second
		CJNE A,#60,NEXT
		LJMP START
DELY1S:		MOV R5,#100
D2:		MOV R6,#20
D1:		MOV R7,#248
		DJNZ R7,$
		DJNZ R6,D1
		DJNZ R5,D2
		RET
TABLE:		DB 3FH,06H,5BH,4FH,66H,6DH,7DH,07H,7FH,6FH
		END
