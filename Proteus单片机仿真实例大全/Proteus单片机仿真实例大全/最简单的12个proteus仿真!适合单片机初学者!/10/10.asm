Count		EQU 30H
SP1		BIT P3.7
		ORG 0
START:		MOV Count,#00H
NEXT:		MOV A,Count
		MOV B,#10
		DIV AB
		MOV DPTR,#TABLE
		MOVC A,@A+DPTR
		MOV P0,A
		MOV A,B
		MOVC A,@A+DPTR
		MOV P2,A
WT:		JNB SP1,WT
WAIT:		JB SP1,WAIT
		LCALL DELY10MS
		JB SP1,WAIT
		INC Count
		MOV A,Count
		CJNE A,#100,NEXT
		LJMP START
DELY10MS:	MOV R6,#20
D1:		MOV R7,#248
		DJNZ R7,$
		DJNZ R6,D1
		RET
TABLE:		DB 3FH,06H,5BH,4FH,66H,6DH,7DH,07H,7FH,6FH
		END
